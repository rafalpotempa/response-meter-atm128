<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lab_01\lab_01.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lab_02_tm_ovf\lab_02_tm_ovf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lab_03_tm_ctc\lab_03_tm_ctc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lab_04_tm_isr\lab_04_tm_isr.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lab_05_7seg\lab_05_7seg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lab_06_7seg_mx\lab_06_7seg_mx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lab_07_kb\lab_07_kb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lab_08_kb_queue\lab_08_kb_queue.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lab_09_hd44\lab_09_hd44.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lab_10_lcd_printf\lab_10_lcd_printf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lab_11_serial\lab_11_serial.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>lab_01</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lab_01</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lab_02_tm_ovf</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lab_02_tm_ovf</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lab_03_tm_ctc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lab_03_tm_ctc</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lab_04_tm_isr</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lab_04_tm_isr</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lab_05_7seg</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lab_05_7seg</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lab_06_7seg_mx</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lab_06_7seg_mx</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lab_07_kb</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lab_07_kb</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lab_08_kb_queue</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lab_08_kb_queue</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lab_09_hd44</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lab_09_hd44</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lab_10_lcd_printf</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lab_10_lcd_printf</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lab_11_serial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lab_11_serial</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


